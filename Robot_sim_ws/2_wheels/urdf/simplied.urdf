Commit message: Add files via upload

File: Robot_sim_ws/2_wheels/urdf/simplied.urdf (robot description, URDF)
Before this commit: robot 2wheels, 4 links, 3 joints
Links:
- link base_link: mass 7.26144947250641 -> 19.1
